Commit message: debug

File: src/robot_simulation/urdf/urdf/robot3.urdf (robot description, URDF)
Before this commit: robot robot_simulation, 8 links, 7 joints
Joints:
- joint joint_4: axis 1 0 0 -> -1 0 0
- joint joint_5: axis 1 0 0 -> -1 0 0
- joint joint_6: axis 1 0 0 -> -1 0 0
